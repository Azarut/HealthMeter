# Keil uVision project STM32F3.uvprojx, settings and files
target Project (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) IRAM2(0x10000000,0x2000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F3
  c flags: Optim=1 wLevel=2
  c define: USE_FULL_ASSERT
  c include: ..\CMSIS\Include;..\CMSIS\Device\ST\STM32F30x\Include;..\STD\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group USER/SRC
    ../SRC/: main.c
  group STD_LIBRARY
    ../STD/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group ::Board Support
    C:/Keil_v5/ARM/PACK/Keil/STM32F3xx_DFP/1.1.0/Boards/ST/STM32F3-Discovery/Common/: Buttons_STM32F3-Discovery.c LED_STM32F3-Discovery.c
  group ::CMSIS
    C:/Keil_v5/ARM/PACK/ARM/CMSIS/4.2.0/CMSIS_RTX/LIB/ARM/: RTX_CM4.lib
    RTE/CMSIS/: RTX_Conf_CM.c
  group ::Device
    RTE/Device/STM32F303VC/: startup_stm32f303xc.s system_stm32f30x.c
software components: CMSIS:CORE 3.40.0, CMSIS:RTOS:Keil RTX 4.75.0, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, Device:Startup 1.2.0
